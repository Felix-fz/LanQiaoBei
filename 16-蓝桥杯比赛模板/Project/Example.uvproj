# Keil uVision project Example.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Example +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Main;..\System
  group Main
    ./: STARTUP.A51
    ../Main/: main.c
  group System
    ../System/: common.c SMG.c interrupt.c
