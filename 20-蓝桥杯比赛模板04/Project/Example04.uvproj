# Keil uVision project Example04.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Example04 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Code\Library;..\Code\Main;..\Code\System
  group Main
    ./: STARTUP.A51
    ../Code/Main/: main.c
  group System
    ../Code/System/: interrupt.c common.c smg.c matrixkey.c
